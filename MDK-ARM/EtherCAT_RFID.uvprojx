# Keil uVision project EtherCAT_RFID.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EtherCAT_RFID +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F10X_MD
  c include: ..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\GD32F10x_standard_peripheral\Include;..\Hardware;..\Firmware\CMSIS;..\User;..\SSC;..\ECAT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c gd32f10x_it.c systick.c
  group Hardware
    ../Hardware/: uart.c spi_ecat.c timer_ecat.c gpio_ecat.c rfid_ecat.c Application.c App_Flash.c wdg_ecat.c
  group ECAT
    ../ECAT/: ecat_api.c
    ./Lib/: ECAT_Core.lib
  group SSC
    ../SSC/: GD32Evb.c ecatappl.c objdef.c SSC-Device.c coeappl.c
  group Firmware/CMSIS
    ../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
    ../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Firmware/GD32_StdPeriph
    ../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_crc.c gd32f10x_dma.c gd32f10x_exti.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_gpio.c gd32f10x_rtc.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_fmc.c

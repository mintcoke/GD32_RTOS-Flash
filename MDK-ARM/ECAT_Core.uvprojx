# Keil uVision project ECAT_Core.uvprojx, settings and files
target ECAT_Core (ARM-ADS)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ECAT_Core (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F10X_MD
  c include: ..\Firmware\CMSIS\GD\GD32F10x\Include;..\Firmware\GD32F10x_standard_peripheral\Include;..\Hardware;..\Firmware\CMSIS;..\User;..\SSC;..\ECAT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SSC
    ../SSC/: mailbox.c sdoserv.c ecatcoe.c ecatslv.c ecatappl.c
